# IAR project RCB.ewp, settings and files
configuration All_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128rfa1 ATmega128RFA1
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..; ../include; ../../../BitCloud/Components/BSP/RCB/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/include/private; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBFIFO/include; ../../../BitCloud/Components/HAL/avr/atmega128rfa1/common/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/ATMEGA128RFA1/MAC_HWD/include
  ICCAVR.PreInclude: MakerulesBc_All_Atmega128rfa1_Atmega128rfa1_Iar.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Coordinator_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; NO_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Coordinator_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Router_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; NO_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Router_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration EndDevice_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; NO_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_EndDevice_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration All_Sec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Sec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Coordinator_Sec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STANDARD_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_Sec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Coordinator_Sec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Router_Sec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STANDARD_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_Sec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Router_Sec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration EndDevice_Sec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STANDARD_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_Sec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_EndDevice_Sec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration All_StdlinkSec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Coordinator_StdlinkSec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration Router_StdlinkSec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
configuration EndDevice_StdlinkSec_Rcb_Atmega128rfa1_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: ATMEGA128RFA1; HAL_8MHz; BOARD_RCB; RCB_ATMEGA128RFA1; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm128rfa1bitcloud.xcl; ../../../BitCloud/lib/libHAL_RcbAtm128rfa1_Atmega128rfa1_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atmega128rfa1_Atmega128rfa1_Iar.a; ../../../BitCloud/lib/WdtInitatmega128rfa1_Iar.o
  group src
    ../src/: blink.c
  group include
    ../include/: blink.h
  group configuration
    ../: configuration.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: pdsMem.c pdsWriteData.c pdsDataServer.c pdsInit.c pdsTimer.c pdsEvents.c pdsMemAccess.c pdsCrcService.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h
  group Components/PersistDataServer/include/private
    ../../../BitCloud/Components/PersistDataServer/include/private/: pdsDbg.h pdsMemAccess.h pdsCrcService.h pdsTimer.h pdsMem.h pdsWriteData.h pdsMemAbstract.h
  group Components/USBFIFO/src
    ../../../BitCloud/Components/HAL/drivers/USBFIFO/src/: usbFifoVirtualUsart.c usbFifoFT245RL.c
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/RCB/src/: leds.c bspTaskManager.c buttons.c fakeBSP.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaulfts.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csParamTable.h csDbg.h csBuffers.h csSIB.h
